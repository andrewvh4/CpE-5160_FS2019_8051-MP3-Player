# Keil uVision project MP3_Player_Software.uvproj, settings and files
target Target 1 (MCS-51)
  device: 89C51 Atmel
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(24000000)
  output: MP3_Player_Software +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./src/Application/: AppMain.c print_bytes.c
    ./src/Drivers/: Memory.c memory_test.c Port.c SPI.c Timing.c UART.c I2C.c Directory_Functions_globals.c UtPorts.c
    ./src/Modules/: LCD.c SDCard.c STA013.c config.asm FAT.c FAT.h
