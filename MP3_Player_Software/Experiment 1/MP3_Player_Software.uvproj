# Keil uVision project MP3_Player_Software.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC2 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM (0-0x3FF) CLOCK(40000000) MODP2
  output: MP3_Player_Software
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 AT89C51RC2.h
    ./src/Application/: Main.h print_bytes.h print_bytes.c Main.c
    ./src/Drivers/: memory_test.h PORT.H memory_test.c UART.c UART.h Timing.c Timing.h
    ./src/Modules/: LCD.c LCD.h
