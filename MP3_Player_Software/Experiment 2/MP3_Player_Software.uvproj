# Keil uVision project MP3_Player_Software.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC2 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM (0-0x3FF) CLOCK(40000000) MODP2
  output: MP3_Player_Software +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: exp_2_fall2019.c LCD_hardware_functions.c LCD_hardware_functions.h LCD_routines.c LCD_Routines.h LED_Outputs.c LED_Outputs.h Long_Serial_In.c Long_Serial_In.h Timer0_hardware_delay_1ms.c Timer0_hardware_delay_1ms.h AT89C51RC2.h Main.h Memory.c Memory.h PORT.H print_bytes.c print_bytes.h SDCard.c SDCard.h SPI.c SPI.h UART.c UART.h
